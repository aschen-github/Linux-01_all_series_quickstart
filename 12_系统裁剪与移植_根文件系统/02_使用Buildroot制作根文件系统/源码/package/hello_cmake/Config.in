## 12_系统裁剪与移植_根文件系统/02_使用Buildroot制作根文件系统/源码/package/hello_cmake/Config.in
```kconfig
config BR2_PACKAGE_HELLO_CMAKE
	bool "hello_cmake"
	help
	  hello_cmake for test.
```
